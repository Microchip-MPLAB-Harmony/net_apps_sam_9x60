# IAR project tcpip_udp_client_server.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN; __SAM9X60__
  ICCARM.CCDiagSuppress: Pe188, Pe186, Pe1029,Pa039
  ICCARM.CCIncludePath2: ..\src\config\sam_9x60_ek_freertos\library; ..\src\config\sam_9x60_ek_freertos\library\tcpip\src; ..\src\config\sam_9x60_ek_freertos\library\tcpip\src\common; ..\src; ..\src\config\sam_9x60_ek_freertos; ..\src\packs\SAM9X60_DFP; .; ..\src\third_party\wolfssl; ..\src\third_party\wolfssl\wolfssl; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\ARM926; ..\src\third_party\rtos\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x60_ek_freertos.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek_freertos\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN; __SAM9X60__; NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: app_commands.c
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos
    ../src/config/sam_9x60_ek_freertos/: device.h system_config.h system_definitions.h user.h configuration.h device_cache.h toolchain_specifics.h definitions.h interrupts.h config.h FreeRTOSConfig.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/bsp
    ../src/config/sam_9x60_ek_freertos/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/pit
    ../src/config/sam_9x60_ek_freertos/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/tc
    ../src/config/sam_9x60_ek_freertos/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/mmu
    ../src/config/sam_9x60_ek_freertos/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/clk
    ../src/config/sam_9x60_ek_freertos/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/pio
    ../src/config/sam_9x60_ek_freertos/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/aic
    ../src/config/sam_9x60_ek_freertos/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/dbgu
    ../src/config/sam_9x60_ek_freertos/peripheral/dbgu/: plib_dbgu_common.h plib_dbgu.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system
    ../src/config/sam_9x60_ek_freertos/system/: sys_time_h2_adapter.h sys_random_h2_adapter.h system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/time
    ../src/config/sam_9x60_ek_freertos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_9x60_ek_freertos/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/int
    ../src/config/sam_9x60_ek_freertos/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/cache
    ../src/config/sam_9x60_ek_freertos/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/reset
    ../src/config/sam_9x60_ek_freertos/system/reset/: sys_reset.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/debug
    ../src/config/sam_9x60_ek_freertos/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/command
    ../src/config/sam_9x60_ek_freertos/system/command/: sys_command.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/console
    ../src/config/sam_9x60_ek_freertos/system/console/: sys_console.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver
    ../src/config/sam_9x60_ek_freertos/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/emac
    ../src/config/sam_9x60_ek_freertos/driver/emac/: drv_emac.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/emac/src
    ../src/config/sam_9x60_ek_freertos/driver/emac/src/: drv_emac_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/emac/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/emac/src/dynamic/: drv_emac_dcpt_lists.h drv_emac_lib.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/miim
    ../src/config/sam_9x60_ek_freertos/driver/miim/: drv_miim.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/miim/src
    ../src/config/sam_9x60_ek_freertos/driver/miim/src/: drv_miim_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/miim/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/miim/src/dynamic/: drv_miim_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/ethphy
    ../src/config/sam_9x60_ek_freertos/driver/ethphy/: drv_ethphy.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/ethphy/src
    ../src/config/sam_9x60_ek_freertos/driver/ethphy/src/: drv_ethphy_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/ethphy/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/ethphy/src/dynamic/: drv_extphy_regs.h drv_extphy_ksz8081.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/library/tcpip
    ../src/config/sam_9x60_ek_freertos/library/tcpip/: tcpip_common_ports.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_heap.h tcpip_helpers.h ndp.h ipv4.h ipv6.h icmpv6.h dhcpv6.h arp.h udp.h tcp.h berkeley_api.h dhcp.h dhcps.h dhcp_server.h zero_conf_link_local.h zero_conf_multicast_dns.h dns.h dnss.h ftp.h ftpc.h icmp.h nbns.h ddns.h telnet.h smtp.h sntp.h http.h http_net.h snmp.h snmpv3.h tcpip_announce.h lldp.h smtpc.h igmp.h tftpc.h tftps.h tcpip_reboot.h iperf.h tcpip_commands.h tcpip.h tcpip_mac_bridge.h tcpip_ethernet.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/library/tcpip/src
    ../src/config/sam_9x60_ek_freertos/library/tcpip/src/: tcpip_heap_alloc.h ndp_manager.h ndp_private.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h icmp_manager.h icmpv6_manager.h arp_manager.h arp_private.h udp_manager.h udp_private.h tcp_manager.h tcp_private.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h dhcp_server_manager.h dhcp_server_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h ftpc_manager.h ftpc_private.h nbns_manager.h ddns_manager.h telnet_manager.h smtp_manager.h sntp_manager.h http_manager.h http_private.h http_net_manager.h http_net_private.h snmp_manager.h snmp_private.h snmpv3_private.h tcpip_announce_manager.h smtpc_manager.h smtpc_private.h igmp_manager.h igmp_private.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h tcpip_reboot_manager.h iperf_manager.h tcpip_commands_manager.h hash_fnv.h link_list.h oahash.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_types.h berkeley_manager.h dhcpv6_manager.h dhcpv6_private.h lldp_manager.h lldp_private.h lldp_tlv.h tcpip_mac_bridge_manager.h tcpip_mac_bridge_private.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/library/tcpip/src/common
    ../src/config/sam_9x60_ek_freertos/library/tcpip/src/common/: helpers.h sys_fs_shell.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/net_pres/pres
    ../src/config/sam_9x60_ek_freertos/net_pres/pres/: net_pres.h net_pres_socketapi.h net_pres_socketapiconversion.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/osal
    ../src/config/sam_9x60_ek_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/crypto
    ../src/config/sam_9x60_ek_freertos/crypto/: crypto.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/instance
    ../src/packs/SAM9X60_DFP/instance/: adc.h aes.h aic.h bsc.h can0.h can1.h classd.h dbgu.h emac0.h emac1.h flexcom0.h flexcom1.h flexcom10.h flexcom11.h flexcom12.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h flexcom8.h flexcom9.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pioa.h piob.h pioc.h piod.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc0.h sdmmc1.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc0.h tc1.h tdes.h trng.h udphs.h uhphs_ehci.h uhphs_ohci.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Header Files/wolfcrypt
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/: arc4.h asn.h asn_public.h blake2-impl.h blake2-int.h blake2.h camellia.h chacha.h chacha20_poly1305.h cmac.h coding.h compress.h cpuid.h cryptocb.h curve25519.h curve448.h des3.h dh.h dsa.h ed25519.h ed448.h error-crypt.h fe_448.h fe_operations.h fips_test.h ge_448.h ge_operations.h hash.h hc128.h hmac.h idea.h integer.h logging.h md2.h md4.h md5.h memory.h mem_track.h misc.h mpi_class.h mpi_superclass.h pkcs11.h pkcs12.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h rc2.h ripemd.h rsa.h selftest.h sha3.h signature.h sp.h sp_int.h srp.h tfm.h visibility.h wc_encrypt.h wc_pkcs11.h wolfevent.h wolfmath.h settings.h aes.h sha.h sha256.h sha512.h wc_port.h ecc.h types.h
    ../src/third_party/wolfssl/wolfssl/: certs_test.h
  group Harmony3/Header Files/wolfcrypt/port
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/port/pic32/: pic32mz-crypt.h CryptoLib_cf_pb.h CryptoLib_ClearFlags_pb.h CryptoLib_Comp_pb.h CryptoLib_CondCopy_pb.h CryptoLib_CRT_pb.h CryptoLib_Div_pb.h CryptoLib_ExpMod_pb.h CryptoLib_FastCopy_pb.h CryptoLib_Fill_pb.h CryptoLib_Fmult_pb.h CryptoLib_GCD_pb.h CryptoLib_GF2NEccAdd_pb.h CryptoLib_GF2NEccConv_pb.h CryptoLib_GF2NEccDbl_pb.h CryptoLib_GF2NEccMul_pb.h CryptoLib_GF2NEcDsa_pb.h CryptoLib_Hardware_pb.h CryptoLib_Headers_pb.h CryptoLib_JumpTable_pb.h CryptoLib_mapping_pb.h CryptoLib_PrimeGen_pb.h CryptoLib_Rc_pb.h CryptoLib_RedMod_pb.h CryptoLib_Rng_pb.h CryptoLib_SelfTest_pb.h CryptoLib_Services_pb.h CryptoLib_Smult_pb.h CryptoLib_Square_pb.h CryptoLib_Swap_pb.h CryptoLib_typedef_pb.h CryptoLib_ZpEccAddSub_pb.h CryptoLib_ZpEccAdd_pb.h CryptoLib_ZpEccConv_pb.h CryptoLib_ZpEccDbl_pb.h CryptoLib_ZpEccMul_pb.h CryptoLib_ZpEccQuickDualMul_pb.h CryptoLib_ZpEcDsa_pb.h crypt_aes_hw.h crypt_aes_hwInt.h crypt_aes_sam6149.h crypt_aes_u2238.h crypt_crya_saml11.h crypt_ecc_ba414e.h crypt_ecc_pukcl.h crypt_pukcl_definitions.h crypt_pukcl_functions.h crypt_rng_hw.h crypt_rsa_pukcl.h crypt_sha1_hw.h crypt_sha224_hw.h crypt_sha256_hw.h crypt_sha384_hw.h crypt_sha512_hw.h crypt_sha_hw.h crypt_sha_sam11105.h crypt_sha_sam6156.h crypt_tdes_hw.h crypt_tdes_hwInt.h crypt_tdes_sam6150.h crypt_wolfcryptcb.h
  group Harmony3/Header Files/FreeRTOS/Source/include
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h deprecated_definitions.h task.h timers.h mpu_prototypes.h stream_buffer.h message_buffer.h
  group Harmony3/Header Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: portmacro.h
  group Harmony3/Source Files
    ../src/: app.c main_sam_9x60.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos
    ../src/config/sam_9x60_ek_freertos/: tasks.c initialization.c interrupts.c cstartup.s vectortrap.s freertos_hooks.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/bsp
    ../src/config/sam_9x60_ek_freertos/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/library/tcpip/src
    ../src/config/sam_9x60_ek_freertos/library/tcpip/src/: icmp.c nbns.c tcp.c arp.c tcpip_commands.c ipv4.c tcpip_heap_alloc.c tcpip_heap_internal.c dhcp.c dns.c hash_fnv.c oahash.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c tcpip_announce.c udp.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/library/tcpip/src/common
    ../src/config/sam_9x60_ek_freertos/library/tcpip/src/: helpers.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/pit
    ../src/config/sam_9x60_ek_freertos/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/tc
    ../src/config/sam_9x60_ek_freertos/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/mmu
    ../src/config/sam_9x60_ek_freertos/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/clk
    ../src/config/sam_9x60_ek_freertos/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/pio
    ../src/config/sam_9x60_ek_freertos/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/aic
    ../src/config/sam_9x60_ek_freertos/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/dbgu
    ../src/config/sam_9x60_ek_freertos/peripheral/dbgu/: plib_dbgu.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system
    ../src/config/sam_9x60_ek_freertos/system/: sys_time_h2_adapter.c sys_random_h2_adapter.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/time
    ../src/config/sam_9x60_ek_freertos/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/console
    ../src/config/sam_9x60_ek_freertos/system/console/src/: sys_console_uart.h sys_console_uart_definitions.h sys_console_uart.c sys_console.c sys_console_local.h
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/int
    ../src/config/sam_9x60_ek_freertos/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/cache
    ../src/config/sam_9x60_ek_freertos/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/reset
    ../src/config/sam_9x60_ek_freertos/system/reset/: sys_reset.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/command
    ../src/config/sam_9x60_ek_freertos/system/command/src/: sys_command.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/debug
    ../src/config/sam_9x60_ek_freertos/system/debug/src/: sys_debug_local.h sys_debug.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/driver/emac/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/emac/src/dynamic/: drv_emac.c drv_emac_statistics.c drv_emac_lib_SAM9X60.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/driver/miim/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/miim/src/dynamic/: drv_miim.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/driver/ethphy/src/dynamic
    ../src/config/sam_9x60_ek_freertos/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8081.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/osal
    ../src/config/sam_9x60_ek_freertos/osal/: osal_freertos.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/stdio
    ../src/config/sam_9x60_ek_freertos/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/crypto
    ../src/config/sam_9x60_ek_freertos/crypto/src/: crypto.c
  group Harmony3/Source Files/wolfcrypt
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/: arc4.c asm.c asn.c blake2b.c blake2s.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c cryptocb.c curve25519.c curve448.c dh.c dsa.c ecc_fp.c ed25519.c ed448.c error.c fe_448.c fe_low_mem.c fe_operations.c ge_448.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c rc2.c ripemd.c rsa.c sha3.c signature.c sp_arm32.c sp_arm64.c sp_armthumb.c sp_c32.c sp_c64.c sp_cortexm.c sp_dsp32.c sp_int.c sp_x86_64.c srp.c tfm.c wc_dsp.c wc_encrypt.c wc_pkcs11.c wc_port.c wolfevent.c wolfmath.c aes.c des3.c random.c sha.c sha256.c sha512.c ecc.c
  group Harmony3/Source Files/wolfcrypt/port
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/port/pic32/: pic32mz-crypt.c crypt_aes_sam6149.c crypt_aes_u2238.c crypt_ecc_ba414e.c crypt_ecc_pukcl.c crypt_pukcl_functions.c crypt_rng_sam6334.c crypt_rng_u2242.c crypt_rsa_pukcl.c crypt_sam_u2803.c crypt_sha1_sam11105.c crypt_sha1_sam6156.c crypt_sha224_sam11105.c crypt_sha224_sam6156.c crypt_sha256_sam11105.c crypt_sha256_sam6156.c crypt_sha384_sam6156.c crypt_sha512_sam6156.c crypt_tdes_sam6150.c crypt_wolfcryptcb.c
  group Harmony3/Source Files/FreeRTOS/Source
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c list.c queue.c FreeRTOS_tasks.c timers.c event_groups.c stream_buffer.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/MemMang
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_3.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: port.c portASM.s FreeRTOS_tick_config.c
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek_freertos/: ddram.icf
